require emacs-x11_cvs.bb

SRCDATE = "20060801"

