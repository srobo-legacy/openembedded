LICENSE = "LGPL"
DEPENDS = "glib-2.0 dbus system-tools-backends"

inherit gnome lib_package

