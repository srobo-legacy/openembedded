LICENSE = "LGPL"
DEPENDS = "glib-2.0"

inherit gnome lib_package

