require mingw-binutils_${PV}.bb
require binutils-canadian-cross.inc
