require vala.inc
PR = "${INC_PR}.0"

BBCLASSEXTEND="native"
