require xapian-quickstart.inc

DESCRIPTION += "This package provides the tool for creating the index."
PR = "r1"

BBCLASSEXTEND="native"
