require yasm.inc


BBCLASSEXTEND="native"
