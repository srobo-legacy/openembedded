require libmrss.inc

# this version misses the patch applied to 0.17.2 - needs patch rebase
PR = "${INC_PR}.1"

