PR = "r0"

require byacc.inc

BBCLASSEXTEND="native"
