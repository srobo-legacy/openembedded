PR = "r0"

require make.inc

BBCLASSEXTEND="native"
