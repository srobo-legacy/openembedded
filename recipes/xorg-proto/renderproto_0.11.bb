require xorg-proto-common.inc

CONFLICTS = "renderext"
PE = "1"

BBCLASSEXTEND="native sdk"
