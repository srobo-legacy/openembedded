require devio.inc

BBCLASSEXTEND="native"
