require devio-cvs.inc

BBCLASSEXTEND="native"
