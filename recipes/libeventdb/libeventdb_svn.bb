require libeventdb.inc

PR = "r1"
PV = "0.90+svn${SRCDATE}"
SRC_URI = "${GPE_SVN}"
S = "${WORKDIR}/${PN}"
