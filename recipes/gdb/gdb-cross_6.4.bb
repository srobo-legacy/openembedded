require gdb-cross.inc

PR = "r1"