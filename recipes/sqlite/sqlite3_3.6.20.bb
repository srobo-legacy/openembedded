require sqlite3.inc

BBCLASSEXTEND="native"

