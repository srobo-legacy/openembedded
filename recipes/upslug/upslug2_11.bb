require upslug2.inc

BBCLASSEXTEND="native"
