require postgresql.inc

PR = "r4"
SRC_URI += "file://no-ecpg-test.patch;patch=1"
