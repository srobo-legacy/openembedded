require lzma.inc
PR = "${INC_PR}.1"

BBCLASSEXTEND="native"
