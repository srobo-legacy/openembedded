PR="${INC_PR}.0"

SRC_URI = " \
	${GNU_MIRROR}/wget/wget-${PV}.tar.gz \
"

require wget.inc
