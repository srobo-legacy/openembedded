require quilt-package.inc

BBCLASSEXTEND="native"
