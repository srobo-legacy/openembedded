require dropbear.inc
PR = "r0"

SRC_URI += "file://no-host-lookup.patch;patch=1"

