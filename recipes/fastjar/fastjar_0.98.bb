require fastjar.inc

BBCLASSEXTEND="native"
