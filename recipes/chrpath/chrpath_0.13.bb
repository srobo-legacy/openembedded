require chrpath.inc

BBCLASSEXTEND="native"
