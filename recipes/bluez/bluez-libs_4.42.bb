require bluez4-libs.inc

PR = "${INC_PR}.1"
