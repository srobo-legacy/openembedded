require lighttpd.inc

PR = "${INC_PR}.0"

